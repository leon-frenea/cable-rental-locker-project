# Keil uVision project ArmoirSecu.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ArmoirSecu
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c ADXL345.h cable.c uart.c utils.c fifo.c servo.c adxl.c rfid.c cable.h uart.h fifo.h servo.h adxl.h rfid.h utils.h bsp.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
